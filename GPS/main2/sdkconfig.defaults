## GPS/main2/sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_ESPTOOLPY_FLASHSIZE_2MB=y
CONFIG_LIBC_STDOUT_LINE_ENDING_LF=y
```
